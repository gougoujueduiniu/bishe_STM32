# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\user;.\cmsis;.\library\inc;.\starup;.\library\src;.\driver;.\SYSTEM\sys
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group library
    ./library/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c
  group cmsis
    ./cmsis/: core_cm3.c system_stm32f10x.c
  group starup
    ./starup/: startup_stm32f10x_md.s
  group user
    ./user/: main.c stm32f10x_it.c
  group driver
    ./driver/: readme.txt delay.c pwm.c xunji.c mlx90614.c oled.c adckey.c exit.c usart2.c utils.c timer.c
  group sys
    ./SYSTEM/sys/: sys.c
